<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\core_cm3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\startup_stm32f10x_md.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\CMSIS\system_stm32f10x.c</name>
    </file>
  </group>
  <group>
    <name>StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_bkp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_cec.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Libraries\Stm32f10x_StdDrivers\Lib\src\stm32f10x_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>uCOS</name>
    <group>
      <name>uC-CPU</name>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-CPU\Ports\IAR\cpu_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-CPU\Ports\IAR\cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-CPU\Source\cpu_core.c</name>
      </file>
    </group>
    <group>
      <name>uC-LIB</name>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-LIB\Source\lib_ascii.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-LIB\Source\lib_math.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-LIB\Source\lib_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-LIB\Ports\ARM-Cortex-M3\IAR\lib_mem_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-LIB\Source\lib_str.c</name>
      </file>
    </group>
    <group>
      <name>uCOS-III</name>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_cfg_app.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_dbg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_flag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_msg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_mutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_pend_multi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_prio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_q.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_sem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_stat.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_tick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_tmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Source\os_var.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>StmLib-Cfg</name>
      <file>
        <name>$PROJ_DIR$\..\User\stm32f10x_conf.h</name>
      </file>
    </group>
    <group>
      <name>uCOS-Cfg</name>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-CPU\Cfg\cpu_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uC-LIB\Cfg\lib_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Cfg\os_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\uCOS\uCOS-III\Cfg\os_cfg_app.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\User\bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\User\main.c</name>
    </file>
  </group>
</project>


