# IAR project bbucos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..\User; ..\uCOS\uC-CPU\Source; ..\uCOS\uC-CPU\Ports\IAR; ..\uCOS\uC-CPU\Cfg; ..\uCOS\uC-LIB\Source; ..\uCOS\uC-LIB\Ports\ARM-Cortex-M3\IAR; ..\uCOS\uC-LIB\Cfg; ..\uCOS\uCOS-III\Source; ..\uCOS\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; ..\uCOS\uCOS-III\Cfg; ..\Libraries\CMSIS; ..\Libraries\Stm32f10x_StdDrivers\Lib\inc; ..\User\BSP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bbucos.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
  group StdPeriph_Driver
    ../Libraries/Stm32f10x_StdDrivers/Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS/uC-CPU
    ../uCOS/uC-CPU/Ports/IAR/: cpu_a.asm cpu_c.c
    ../uCOS/uC-CPU/Source/: cpu_core.c
  group uCOS/uC-LIB
    ../uCOS/uC-LIB/Source/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../uCOS/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group uCOS/uCOS-III
    ../uCOS/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ../uCOS/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group User
    ../User/: bsp.c main.c systeminit.c
  group User/StmLib-Cfg
    ../User/: stm32f10x_conf.h
  group User/uCOS-Cfg
    ../uCOS/uC-CPU/Cfg/: cpu_cfg.h
    ../uCOS/uC-LIB/Cfg/: lib_cfg.h
    ../uCOS/uCOS-III/Cfg/: os_cfg.h os_cfg_app.h
