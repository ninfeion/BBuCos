# IAR project bbucos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: Users\Stm32f10x_StdDrivers\Lib\inc; Users\Applications\inc; Users\uCos\uCOS-III\Source; Users\uCos\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; Users\uCos\uCOS-III\Cfg; Users\uCos\uC-LIB; Users\uCos\uC-LIB\Cfg; Users\uCos\uC-LIB\Ports\ARM-Cortex-M3\IAR; Users\uCos\uC-CPU; Users\uCos\uC-CPU\ARM-Cortex-M3\IAR; Users\uCos\uC-CPU\Cfg; Users\Startup; Users\BSP\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: bbucos.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    Users/Applications/src/: main.c
    Users/uCos/uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h
  group App/Cfg
    Users/Applications/inc/: app_cfg.h os_cfg_app.h stm32f10x_conf.h
  group BSP
    ./: stm32f10x_flash.icf
  group BSP/Stm_Std_Library/Headers
    Users/Stm32f10x_StdDrivers/Lib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group BSP/Stm_Std_Library/Source
    Users/Stm32f10x_StdDrivers/Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Cfg_Libraries
    Users/uCos/uC-CPU/Cfg/: cpu_cfg.h
    Users/uCos/uC-LIB/Cfg/: lib_cfg.h
    Users/uCos/uCOS-III/Cfg/: os_cfg.h
    Users/uCos/uCOS-III/Source/: os_type.h
  group uC/CPU/Headers
    Users/uCos/uC-CPU/ARM-Cortex-M3/IAR/: cpu.h
    Users/uCos/uC-CPU/: cpu_core.h cpu_def.h
  group uC/CPU/Source
    Users/uCos/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    Users/uCos/uC-CPU/: cpu_core.c
  group uC/LIB/Headers
    Users/uCos/uC-LIB/: lib_ascii.h lib_def.h lib_math.h lib_mem.h lib_str.h
  group uC/LIB/Source
    Users/uCos/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/OS_III
    Users/uCos/uCOS-III/Source/: os_cfg_app.c
  group uC/OS_III/Headers
    Users/uCos/uCOS-III/Source/: os.h
    Users/uCos/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h
  group uC/OS_III/Source
    Users/uCos/uCOS-III/Source/: os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    Users/uCos/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
